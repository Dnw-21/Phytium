# Keil uVision project GD32L233C_Prj.uvprojx, settings and files
target Gd32L233C_START (6220000::V6.22::ARMCLANG)
  device: GD32L233RC GigaDevice
  pack: GigaDevice.GD32L23x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x0008000) IROM(0x08000000,0x0040000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: GD32L233C_Prj +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\gd32_sys;.\Utilities;.\app;.\Firmware\CMSIS\GD\GD32L23x\Include;.\Firmware\GD32L23x_standard_peripheral\Include;.\FreeRTOS\include;.\FreeRTOS\config;.\FreeRTOS\portable\GCC\ARM_CM23_NTZ\non_secure;.\app\task;.\app\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ./app/: main.c data_frame.c data_monitor.c log.c chaos_encrypt.c health_assessment.c wave_monitor.c zdata_adaptive.c
  group Firmware
    ./Firmware/GD32L23x_standard_peripheral/Source/: gd32l23x_adc.c gd32l23x_cau.c gd32l23x_cau_aes.c gd32l23x_cau_des.c gd32l23x_cau_tdes.c gd32l23x_cmp.c gd32l23x_crc.c gd32l23x_ctc.c gd32l23x_dac.c gd32l23x_dbg.c gd32l23x_dma.c gd32l23x_exti.c gd32l23x_fmc.c gd32l23x_fwdgt.c gd32l23x_gpio.c gd32l23x_i2c.c gd32l23x_lptimer.c gd32l23x_lpuart.c gd32l23x_misc.c gd32l23x_pmu.c gd32l23x_rcu.c gd32l23x_rtc.c gd32l23x_slcd.c gd32l23x_spi.c gd32l23x_syscfg.c gd32l23x_timer.c gd32l23x_trng.c gd32l23x_usart.c gd32l23x_vref.c gd32l23x_wwdgt.c
    ./Firmware/GD32L23x_standard_peripheral/Include/: gd32l23x_adc.h gd32l23x_cau.h gd32l23x_cmp.h gd32l23x_crc.h gd32l23x_ctc.h gd32l23x_dac.h gd32l23x_dbg.h gd32l23x_dma.h gd32l23x_exti.h gd32l23x_fmc.h gd32l23x_fwdgt.h gd32l23x_gpio.h gd32l23x_i2c.h gd32l23x_lptimer.h gd32l23x_lpuart.h gd32l23x_misc.h gd32l23x_pmu.h gd32l23x_rcu.h gd32l23x_rtc.h gd32l23x_slcd.h gd32l23x_spi.h gd32l23x_syscfg.h gd32l23x_timer.h gd32l23x_trng.h gd32l23x_usart.h gd32l23x_vref.h gd32l23x_wwdgt.h
  group gd32_sys
    ./gd32_sys/: gd32l23x_it.c gd32l23x_it.h gd32l23x_libopt.h systick.c systick.h
  group Utilities
    ./Firmware/CMSIS/GD/GD32L23x/Source/ARM/: startup_gd32l23x.s
  group CMSIS
    ./Firmware/CMSIS/GD/GD32L23x/Source/: system_gd32l23x.c
    ./Firmware/CMSIS/GD/GD32L23x/Include/: system_gd32l23x.h gd32l23x.h
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/portable/Common/: mpu_wrappers.c
    ./FreeRTOS/portable/GCC/ARM_CM23_NTZ/non_secure/: port.c portasm.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/config/: FreeRTOSConfig.h
  group task
    ./app/task/: danger_task.c data_collect_task.c data_judge_task.c lora_recv_task.c lora_send_task.c sys_common.c warning_task.c
  group BSP
    ./app/BSP/: gd32l233r_eval.c gd32l233r_eval.h wave_capture.c mwcc68_uart.c mwcc68_app.c battery_monitor.c gps.c
software components: CMSIS:CORE 6.1.0
